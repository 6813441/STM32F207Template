# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F407ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER   __KEIL
  c include: .\User;.\Lib\CMSIS\GD\GD32F4xx\Include;.\Lib\FreeRTOS_lib;.\Lib\GD32F4xx_standard_peripheral\Include;.\Lib\SYSTEMVIEW_lib;.\Lib\CMSIS;.\User\bsp;.\Lib\LwIP_lib\include;.\Lib\LwIP_lib\include\netif;.\Lib\LwIP_lib\include\lwip;.\Lib\LwIP_lib\include\compat;.\Lib\LwIP_lib\include\lwip\apps;.\Lib\LwIP_lib\include\lwip\prot;.\Lib\LwIP_lib\include\lwip\priv;.\Lib\LwIP_lib;.\Lib\LwIP_lib\arch;.\User\peripheral
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Link.sct
  group CMSIS
    ./Lib/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./Lib/CMSIS/GD/GD32F4xx/Include/: system_gd32f4xx.h
    ./Lib/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group GD32_lib
    ./Lib/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_wwdgt.c gd32f4xx_usart.c
  group USER
    ./User/: FreeRTOSConfig.h main.c main.h lwipopts.h user_samp.c user_samp.h user_task.c user_task.h user_alarm.c user_alarm.h user_programctrl.c user_programctrl.h user_PC_Data.c user_PC_Data.h user_SysType.c user_SysType.h user_Cali.c user_Cali.h user_Time.c user_Time.h Readme.txt
  group PERIPHERAL
    ./User/peripheral/: user_all_gpio_init.c user_all_gpio_init.h user_cpld.c user_cpld.h user_delay.c user_delay.h AD8688.c AD8688.h FPGA.c FPGA.h SGM4588.c SGM4588.h SGM5349.c SGM5349.h Epwm.c Epwm.h CaptureFrequence.c CaptureFrequence.h ConRelay.c ConRelay.h GD485.c GD485.h AD7606.c AD7606.h
  group BSP_DRIVER
    ./User/bsp/: user_eth.c user_eth.h gd32f4xx_enet_eval.c gd32f4xx_enet_eval.h gd32f4xx_it.c gd32f4xx_it.h user_updata.c user_updata.h user_tcp_server.c user_tcp_server.h
    ./User/: user_ETHCommunication.c user_ETHCommunication.h
  group LwIP/arch
    ./Lib/LwIP_lib/arch/: cc.h ethernetif.c ethernetif.h perf.h sys_arch.c sys_arch.h
  group LwIP/api
    ./Lib/LwIP_lib/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ./Lib/LwIP_lib/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./Lib/LwIP_lib/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ./Lib/LwIP_lib/netif/: bridgeif.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group FreeRTOS
    ./Lib/FreeRTOS_lib/: croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h heap_4.c list.c list.h mpu_prototypes.h mpu_wrappers.h port.c portable.h portmacro.h projdefs.h queue.c queue.h semphr.h StackMacros.h task.h tasks.c timers.c timers.h
  group SYSTEMVIEW
    ./Lib/SYSTEMVIEW_lib/: Global.h SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.h SEGGER_SYSVIEW_Int.h
